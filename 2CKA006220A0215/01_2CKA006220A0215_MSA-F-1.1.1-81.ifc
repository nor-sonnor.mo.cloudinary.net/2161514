Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-10-14T17:35:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 14 17:35:59 2024 * Host: DESKTOP-QJ1AI03 * Database: C:\Users\ROBERT~1\AppData\Local\Temp\{4A3F8148-0074-4EC6-8EFB-0341FF608099}\ifc * Database version: 5507 * Database creation date: Mon Oct 14 17:35:58 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 14 17:35:58 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 14 17:35:58 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello 1; Famiglia e tipo: Livello: Livello 1; ID tipo: Livello: Livello 1; Tipo: Livello: Livello 1
Dati identità - Nome: Livello 1; Piano edificio: no; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello 1

# IfcBuildingElementProxy: 2CKA001754A4240_Cover frame 1gang anthracite, Future linear, 1-gang frame:2CKA001754A4240_Cover frame 1gang anthracite:5668
In: Livello 1
Type - Classification: 2CKA001754A4240 (Uniformat); Material: ABB_anthrazit
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Future linear, 1-gang frame
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: Cover frame 1gang anthracite - future linear; ABB_EANCODE: 4011395050804; ABB_ETIM 7 Logical Attributes: With hinged lid, Label space/information surface, Suitable for floor box, Transparent, Suitable for built-in installation, With mounting grid, Halogen free, Suitable for wall duct, Suitable for flush-mounted installation; ABB_PRODUCT_ID: 2CKA001754A4240; ABB_Product Main Type: future® linear Cover frame; Codice assieme: 2CKA001754A4240; Descrizione: With small corner radii for trunking systems.; Modello: Future linear; Nome del tipo: 2CKA001754A4240_Cover frame 1gang anthracite; Produttore: ABB; URL: https://new.abb.com/low-voltage/products/building-automation/product-range/abb-i-bus-knx/products/visualisation-display-and-signalling/abb-smarttouch-10
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_anthrazit
Type - Vincoli - Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA001754A4240_Cover frame 1gang anthracite
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: no; Famiglia: Future linear, 1-gang frame: 2CKA001754A4240_Cover frame 1gang anthracite; Famiglia e tipo: Future linear, 1-gang frame: 2CKA001754A4240_Cover frame 1gang anthracite; ID tipo: Future linear, 1-gang frame: 2CKA001754A4240_Cover frame 1gang anthracite; Tipo: Future linear, 1-gang frame: 2CKA001754A4240_Cover frame 1gang anthracite
Dati identità - Contrassegno: 2
Dimensioni - Area: 0.00837356 m2; Volume: 0.0000747975 m3
Elettrico - Carichi - Fattore di richiesta totale: 1; Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Sposta con l'oggetto più vicino: no

# IfcBuildingElementProxy: 2CKA006220A0215_MSA-F-1.1.1-81, Movement detector, Relay, Future linear_1:2CKA006220A0215_MSA-F-1.1.1-81:5667
In: Livello 1
Type - Classification: 2CKA006220A0215 (Uniformat); Material: ABB_anthrazit, ABB_Glass, ABB_White, ABB_Gray, ABB_Logo Material
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Movement detector, Relay, Future linear_1
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: MSA-F-1.1.1-81 Mov. detector/actuator 1g; ABB_EANCODE: 4011395179840; ABB_ETIM 7 Logical Attributes: Radio frequent bidirectional, Staircase monitoring, Animal zone, Response value luminosity adjustable; ABB_PRODUCT_ID: 2CKA006220A0215; ABB_Product Main Type: Movement detector/switch actuator, 1gang; Codice assieme: 2CKA006220A0215; Descrizione: With select lens for detection with animal access. For automatic switching of ABB-free@home® actuators dependent on movement and brightness. Switch-off delay of the actuator can be programmed via the web interface of the System Access Point. For switching 127 V~/230 V~ consumers. With integrated switch actuator. Switching function is available also without prior programming (pre-configured). Configuration can be changed later via the web interface (groups, scenes, etc.). The bus can be connected via enclosed terminal block. When installing in the flush-mounted box, a spatial division between the bus cable and 127 V/230 V installation cable is to be adhered to! If this minimum distance is not possible, use electronic boxes or insulating tubes.; Modello: Movement detector/switch actuator, 1gang; Nome del tipo: 2CKA006220A0215_MSA-F-1.1.1-81; Produttore: ABB; URL: https://new.abb.com/products/2CKA006220A0215/msa-f-1-1-1-81
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_anthrazit
Type - Vincoli - Frame: Future linear, 1-gang frame: 2CKA001754A4240_Cover frame 1gang anthracite; Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA006220A0215_MSA-F-1.1.1-81
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: yes; Famiglia: Movement detector, Relay, Future linear_1: 2CKA006220A0215_MSA-F-1.1.1-81; Famiglia e tipo: Movement detector, Relay, Future linear_1: 2CKA006220A0215_MSA-F-1.1.1-81; ID tipo: Movement detector, Relay, Future linear_1: 2CKA006220A0215_MSA-F-1.1.1-81; Tipo: Movement detector, Relay, Future linear_1: 2CKA006220A0215_MSA-F-1.1.1-81
Dati identità - Contrassegno: 1
Dimensioni - Area: 0.01504 m2; Volume: 0.000343966 m3
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Fattore di richiesta totale: 1; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Dati elettrici: 0 V/1-0 VA
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Prospetto: 0 mm
